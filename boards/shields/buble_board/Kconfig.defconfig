## boards/shields/buble_board/Kconfig.defconfig
```kconfig
if SHIELD_BUBLE_BOARD

config ZMK_KEYBOARD_NAME
    default "buble_board"

endif # SHIELD_BUBLE_BOARD
```
